Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20140212_CAD-objekt_Göran_prio2\ARBETSMAPP\16410000\AutoCAD Architecture\16410000.ifc
Time: 2014-03-04T12:47:43
Author: - -
Organization: Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 16410000
LongName: 16410000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 16410000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 16410000, BUILDINGELEMENTPROXY(1)
In: 16410000
Description: FM Mattsson 16410000, 9000E Tronic washbasin mixer, with temperature lever, chrome
